<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\A3DPDemo_SNK.ewp</path>
  </project>
  <batchBuild/>
</workspace>


