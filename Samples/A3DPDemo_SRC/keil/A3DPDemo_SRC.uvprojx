# Keil uVision project A3DPDemo_SRC.uvprojx, settings and files
target Debug (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: MSP432P401R Texas Instruments
  pack: TexasInstruments.MSP432.1.0.2
  cpu: IROM(0x00000000,0x00040000) IROM2(0x00200000,0x00004000) IRAM(0x20000000,0x00010000) IRAM2(0x01000000,0x00010000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: A3DPDemo_SRC
  c flags: Optim=1 uC99=1 wLevel=2
  c define: __MSP432P401R__ TARGET_IS_MSP432P4XX keil __USE_ANSI_EXAMPLE_RAND __SUPPORT_AUDIO_CODEC__ __SUPPORT_AVPR__
  c misc: --sys_include
  c include: ..;..\..\..\Platforms\driverlib;..\..\..\Platforms\MSP-EXP432P401R;..\..\..\Bluetopia\include;..\..\..\Bluetopia\btpskrnl;..\..\..\Bluetopia\hcitrans;..\..\..\Bluetopia\btpsvend;..\..\..\Bluetopia\btvs;..\..\..\Bluetopia\profiles\a2dp\include;..\..\..\Bluetopia\profiles\audio\include;..\..\..\Bluetopia\profiles\avctp\include;..\..\..\Bluetopia\profiles\avrcp\include;..\..\..\Bluetopia\profiles\gavd\include
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT5: ROM 0x200000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1000000 size 0x10000
  group Application
    ../: A3DPDemo_SRC.c A3DPDemo_SRC.h Main.c Main.h
  group Bluetopia
    ../../../Bluetopia/btpskrnl/: BTPSKRNL.c
    ../../../Bluetopia/btpsvend/: BTPSVEND.c
    ../../../Bluetopia/btvs/: BTVS.c
    ../../../Bluetopia/hcitrans/: HCITRANS.c
  group driverlib
    ../../../Platforms/driverlib/: adc14.c aes256.c comp_e.c cpu.c crc32.c cs.c dma.c flash.c fpu.c gpio.c i2c.c interrupt.c mpu.c pcm.c pmap.c pss.c ref_a.c reset.c rtc_c.c spi.c sysctl.c systick.c timer_a.c timer32.c uart.c wdt_a.c
  group MSP-EXP432P401R
    ../../../Platforms/MSP-EXP432P401R/: HAL.c HAL.h HRDWCFG.h CC3200AUDBOOST.c CC3200AUDBOOST.h
    ../../../Platforms/MSP-EXP432P401R/keil/: startup_MSP432P4.s
  group Libraries
    ../../../Bluetopia/lib/keil/: Bluetopia_BR_EDR.lib
    ../../../Bluetopia/profiles/audio/lib/keil/: SS1BTAUD.lib
    ../../../Bluetopia/profiles/avctp/lib/keil/: SS1BTAVC.lib
    ../../../Bluetopia/profiles/avrcp/lib/keil/: SS1BTAVR.lib
    ../../../Bluetopia/profiles/gavd/lib/keil/: SS1BTGAV.lib
target Release (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: MSP432P401R Texas Instruments
  pack: TexasInstruments.MSP432.1.0.2
  cpu: as above
  output: A3DPDemo_SRC
  c flags: Optim=4 uC99=1 wLevel=2
  c define: as above
  c misc: --sys_include
  c include: as above
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT5: ROM 0x200000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1000000 size 0x10000
software components: CMSIS:CORE 3.40.0
