# IAR project A3DPDemo_SRC.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MSP432P401R TexasInstruments MSP432P401R
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: __MSP432P401R__; ewarm; __SUPPORT_AUDIO_CODEC__; __SUPPORT_AVPR__
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.PreInclude: msp432p401r.h
  ICCARM.CCIncludePath2: ..\..\..\Platforms\driverlib; ..; $TOOLKIT_DIR$\inc\TexasInstruments; $TOOLKIT_DIR$\inc\TexasInstruments\CMSIS; $TOOLKIT_DIR$\CMSIS\Include; ..\..\..\Platforms\MSP-EXP432P401R; ..\..\..\Bluetopia\include; ..\..\..\Bluetopia\btpskrnl; ..\..\..\Bluetopia\btpsvend; ..\..\..\Bluetopia\btvs; ..\..\..\Bluetopia\hcitrans; ..\..\..\Bluetopia\profiles\a2dp\include; ..\..\..\Bluetopia\profiles\audio\include; ..\..\..\Bluetopia\profiles\avctp\include; ..\..\..\Bluetopia\profiles\avrcp\include; ..\..\..\Bluetopia\profiles\gavd\include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: A3DPDemo_SRC.srec
  ILINK.IlinkOutputFile: A3DPDemo_SRC.out
  ILINK.IlinkAdditionalLibs: ..\..\..\Bluetopia\lib\ewarm\Bluetopia_BR_EDR.lib; ..\..\..\Bluetopia\profiles\audio\lib\ewarm\SS1BTAUD.lib; ..\..\..\Bluetopia\profiles\avctp\lib\ewarm\SS1BTAVC.lib; ..\..\..\Bluetopia\profiles\avrcp\lib\ewarm\SS1BTAVR.lib; ..\..\..\Bluetopia\profiles\gavd\lib\ewarm\SS1BTGAV.lib
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; __MSP432P401R__; ewarm; __SUPPORT_AUDIO_CODEC__; __SUPPORT_AVPR__
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  group Application
    ../: A3DPDemo_SRC.c A3DPDemo_SRC.h Main.c Main.h
  group Bluetopia/btpskrnl
    ../../../Bluetopia/btpskrnl/: BKRNLAPI.h BTPSKRNL.c BTPSKRNL.h
  group Bluetopia/btpsvend
    ../../../Bluetopia/btpsvend/: BTPSVEND.c BTPSVEND.h BVENDAPI.h CC256X.h CC256XB.h
  group Bluetopia/btvs
    ../../../Bluetopia/btvs/: BTVS.c BTVSAPI.h SS1BTVS.h
  group Bluetopia/hcitrans
    ../../../Bluetopia/hcitrans/: HCITRANS.c HCITRANS.h
  group Bluetopia/include
    ../../../Bluetopia/include/: BaseTypes.h BSCAPI.h BTAPITyp.h BTBTypes.h BTErrors.h BTPSCFG.h BTPSVER.h BTTypes.h GAPAPI.h GOEPAPI.h HCIAPI.h HCICommT.h HCIDRV.h HCITypes.h HCIUSBT.h L2CAPAPI.h L2CAPTyp.h OBXTypes.h OTPAPI.h RFCOMAPI.h RFCOMMT.h SCOAPI.h SDPAPI.h SDPTypes.h SMTypes.h SPPAPI.h SS1BTPS.h
  group Platforms/driverlib
    ../../../Platforms/driverlib/: adc14.c adc14.h aes256.c aes256.h comp_e.c comp_e.h cpu.c cpu.h crc32.c crc32.h cs.c cs.h debug.h dma.c dma.h driverlib.h eusci.h flash.c flash.h fpu.c fpu.h gpio.c gpio.h i2c.c i2c.h interrupt.c interrupt.h mpu.c mpu.h pcm.c pcm.h pmap.c pmap.h pss.c pss.h ref_a.c ref_a.h reset.c reset.h rom.h rom_map.h rtc_c.c rtc_c.h spi.c spi.h sysctl.c sysctl.h systick.c systick.h timer32.c timer32.h timer_a.c timer_a.h uart.c uart.h wdt_a.c wdt_a.h
  group Platforms/MSP-EXP432P401R
    ../../../Platforms/MSP-EXP432P401R/: CC3200AUDBOOST.c CC3200AUDBOOST.h HAL.c HAL.h HRDWCFG.h
  group Platforms/MSP-EXP432P401R/ewarm
    ../../../Platforms/MSP-EXP432P401R/ewarm/: msp432_startup_ewarm.c
