<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\PBAPDemo.ewp</path>
  </project>
  <batchBuild/>
</workspace>


